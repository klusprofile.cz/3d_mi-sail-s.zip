Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 4c19f3d2-fa12-4c08-9c5c-44c8d79079ad, NumberOfSaves: 14], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2023-12-19T11:11:29+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.0.63 (ENU) - IFC 24.1.1.6

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcDistributionPort, Port_325782_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: KLUŚ - MIFOR - MI-SAIL-S:Silver anodized - 3000 K - 1530 lm, KLUŚ - MIFOR - MI-SAIL-S:Silver anodized - 3000 K - 1530 lm:325782
In: Level 0
Type - Material: Steel, Aluminum, Silver Anodized, PC - 3000 K
Type - Other - Category: Lighting Fixtures; Color: silver anodized; Control: ON/OFF; Cover: frosted; Dimensions L x W x H: 722.4 x 533.4 x 87.2; Family Name: KLUŚ - MIFOR - MI-SAIL-S; Lighting direction: down; Material: aluminum; Mounting type: suspended; Weight: 1.58 kg; Working temperature: 10°C - 30°C
Type - Constraints - Cord length max: 3000 mm; Cord length min: 100 mm; Default Elevation: 0 mm
Type - Data - Color rendering index: 90 CRI; Color temperature: 3000 K; Efficiency: 72 lm/W; IP protection rating: IP20; Luminare power: 21 W; Luminous flux of the fixture: 1530 lm; MacAdam’s ellipse: 3 SDCM; Protection class: III; Supply voltage: 24 V
Type - Dimensions - Light Source Symbol Size: 100 mm
Type - Electrical - Loads - Apparent Load: 21 W; Input voltage: 24 V; Power consumption: 21 W; Power factor: 1
Type - General - OmniClassCode: 23.80.70.11.14.11; OmniClassTitle: Downlights; Uniclass2015Code: Pr_70_70_48_24; Uniclass2015Title: Downlights; Uniclass2015Version: Products v1.31
Type - Identity Data - Author: www.archispace.pl; Manufacturer: KLUŚ Sp. z o.o.; Model: MI-MOON; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Ref No: FPMI031-01300B; System: MIFOR-70; Type Name: Silver anodized - 3000 K - 1530 lm; URL: https://klusdesign.eu/en
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Illuminance: 52.4218 lx; Initial Color Temperature: 3000 K; Light Source Definition (family): Point+HemiSpherical; Luminous Flux: 1530 lm; Luminous Intensity: 487.014 cd; Total Light Loss Factor: 1; Wattage: 10.3001 W
Type - Materials and Finishes - Body material: Aluminum, Silver Anodized; Diffuser material: PC - 3000 K
Type - Pset_ElementShading - Color: silver anodized
Type - Pset_ManufacturerTypeInformation - Manufacturer: KLUŚ Sp. z o.o.
Pset_DistributionFlowElementCommon - Reference: KLUŚ - MIFOR - MI-SAIL-S:Silver anodized - 3000 K - 1530 lm; sets with these values: 2
Other - Family: KLUŚ - MIFOR - MI-SAIL-S; Family and Type: KLUŚ - MIFOR - MI-SAIL-S: Silver anodized - 3000 K - 1530 lm; Type: Silver anodized - 3000 K - 1530 lm; Type Id: 325743
Constraints - Elevation from Level: 555 mm; Host: Reference Plane; Level: Level 0; Offset from the ceiling - desired: 500 mm; Offset from the ceiling - real: 500 mm; Schedule Level: Level 0
Dimensions - Area: 0.157323 m2; Volume: 0.00502163 m3
Electrical - Circuiting - Electrical Data: 24.00 V 24 V/1-21 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 14
Phasing - Phase Created: New Construction
